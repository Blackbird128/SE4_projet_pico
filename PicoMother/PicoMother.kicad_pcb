# Repository Blackbird128/SE4_projet_pico

File readme.md:

# Projet Pico ordinateur 

Lors de ce projet nous avons réalisé une carte mère qui interface avec plusieurs cartes filles développées par d'autres binômes

## Organisation du dépôt GIT :

+ Bootloader : ce dossier contient les bootloader des 328p et 8u2 ainsi qu'un programme blink qui nous a permis de tester nos Atmega
+ OS : ce dossier contient le système d'exploitation de notre carte avec l'ordonnanceur et les differentes fonctions (ISP, S7S, Serie...)
+ PicoMother : ce dossier contient le projet Kicad de notre carte mère
+ PicoShield : ce dossier contient le projet Kicad du Shield pour Arduino et les differents codes des focntions que nous avons testées (S7S, Série, UART et SD)
+ SysFich : ce dossier contient notre système de fichiers

## KiCad design PicoMother/PicoMother.kicad_pcb

Parts:
C7: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C11, C13: 22p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D5, D6: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J8: M20-9980345; PinHeader_2x03_P2.54mm_Vertical
J9: USB_C; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
R1: 1M; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4: 5k1; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9, R10: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R12: 22R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U5: ATmega8U2-A; TQFP-32_7x7mm_P0.8mm
Y4: Crystal_GND24; Crystal_SMD_SeikoEpson_FA238-4Pin_3.2x2.5mm_HandSoldering

Connections:
CC1: J9.A5 (CC1), R3.1
CC2: J9.B5 (CC2), R4.1
D+: R12.2, U5.29 (D+)
D-: R11.2, U5.30 (D-)
DTR: U5.13 (~HWB/PD7); also elsewhere on the board
GND: C7.1, C9.2, C11.2, C13.2, D1.2 (A), J8.6, J9.A1 (GND), J9.A12 (GND), J9.B1 (GND), J9.B12 (GND), J9.S1 (SHIELD), R3.2, R4.2, U5.3 (GND), U5.28 (UGND), Y4.2, Y4.4; also elsewhere on the board
M8RXD: U5.9 (PD3); also elsewhere on the board
M8TXD: U5.8 (PD2); also elsewhere on the board
MISO2: J8.1, U5.17 (PB3)
MOSI2: J8.4, U5.16 (PB2)
unnamed: D1.1 (K), R6.2
unnamed: D5.2 (A), R9.1
unnamed: D6.2 (A), R10.1
unnamed: J9.A6 (D+), J9.B6 (D+), R12.1
unnamed: J9.A7 (D-), J9.B7 (D-), R11.1
unnamed: C11.1, R1.2, U5.2 (PC0/XTAL2), Y4.1
unnamed: C7.2, U5.27 (UCAP)
unnamed: C13.1, R1.1, U5.1 (XTAL1), Y4.3
RESET2: J8.5, R8.2, U5.24 (PC1/~RESET)
RXLED: D6.1 (K), U5.10 (PD4)
SCK2: J8.3, U5.15 (PB1)
TXLED: D5.1 (K), U5.11 (PD5)
USBVCC: C9.1, J8.2, J9.A4 (VBUS), J9.A9 (VBUS), J9.B4 (VBUS), J9.B9 (VBUS), R6.1, R8.1, R9.2, R10.2, U5.4 (VCC), U5.31 (UVCC), U5.32 (AVCC); also elsewhere on the board

Notes on the sheet:
AtMega8u2
USB C
LEDS
ISP 8u2

Parts:
C1, C6: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4, C5: 22p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J7: M20-9980345; PinHeader_2x03_P2.54mm_Vertical
R2, R5, R13: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7: 1M; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_Push; SW_Push_1P1T_NO_CK_KSC7xxJ
U4: ATmega328P-A; TQFP-32_7x7mm_P0.8mm
Y1: Crystal_GND24; Crystal_SMD_SeikoEpson_FA238-4Pin_3.2x2.5mm_HandSoldering

Connections:
CS1: U4.24 (PC1); also elsewhere on the board
CS2: U4.26 (PC3); also elsewhere on the board
CS3: R2.1, U4.30 (PD0); also elsewhere on the board
CS4: U4.11 (PD7); also elsewhere on the board
CS5: U4.2 (PD4); also elsewhere on the board
CS_SD: U4.14 (PB2); also elsewhere on the board
DTR: C1.1, R13.1; also elsewhere on the board
GND: C4.2, C5.2, C6.1, J7.6, R13.2, SW1.1, U4.3 (GND), U4.5 (GND), U4.21 (GND), Y1.2, Y1.4; also elsewhere on the board
INT1: U4.25 (PC2); also elsewhere on the board
INT2: U4.28 (PC5); also elsewhere on the board
INT3: U4.12 (PB0); also elsewhere on the board
INT4: U4.9 (PD5); also elsewhere on the board
INT5: U4.32 (PD2); also elsewhere on the board
M8RXD: R2.2; also elsewhere on the board
M8TXD: R5.1; also elsewhere on the board
MISO: J7.1, U4.16 (PB4); also elsewhere on the board
MOSI: J7.4, U4.15 (PB3); also elsewhere on the board
unnamed: R5.2, U4.31 (PD1)
unnamed: C4.1, R7.1, U4.7 (XTAL1/PB6), Y1.3
unnamed: C5.1, R7.2, U4.8 (XTAL2/PB7), Y1.1
RESET: C1.2, J7.5, R14.2, SW1.2, U4.29 (~RESET/PC6)
RST1: U4.23 (PC0); also elsewhere on the board
RST2: U4.27 (PC4); also elsewhere on the board
RST3: U4.13 (PB1); also elsewhere on the board
RST4: U4.10 (PD6); also elsewhere on the board
RST5: U4.1 (PD3); also elsewhere on the board
SCK: J7.3, U4.17 (PB5); also elsewhere on the board
USBVCC: C6.2, J7.2, R14.1, U4.4 (VCC), U4.6 (VCC), U4.18 (AVCC); also elsewhere on the board

Notes on the sheet:
AtMega 328p
ISP 328p

Parts:
C2, C3: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D4, D7, D8, D9, D10: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1, J2, J3, J4, J5: Conn_02x04_Counter_Clockwise; IDC-Header_2x04_P2.54mm_Vertical
J6: Micro_SD; microSD_HC_Molex_104031-0811
R15, R16, R17, R18: 3.3k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R19, R20, R21, R22, R23: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: 74LVC125; SOIC-14_3.9x8.7mm_P1.27mm
U2: LM1117-3.3; SOT-23

Connections:
+3V3: C3.1, J6.4 (VDD), U1.14 (VCC), U2.2 (VO)
CS1: J1.8, R19.1; also elsewhere on the board
CS2: J2.8, R20.1; also elsewhere on the board
CS3: J3.8, R21.1; also elsewhere on the board
CS4: J4.8, R22.1; also elsewhere on the board
CS5: J5.8, R23.1; also elsewhere on the board
CS_SD: R15.1; also elsewhere on the board
CS_SD_3v3: J6.2 (DAT3/CD), U1.8
GND: C2.2, C3.2, D4.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), J1.1, J2.1, J3.1, J4.1, J5.1, J6.6 (VSS), J6.11 (SHIELD), U1.1, U1.4, U1.7 (GND), U1.10, U1.13, U2.1 (GND); also elsewhere on the board
INT1: J1.4; also elsewhere on the board
INT2: J2.4; also elsewhere on the board
INT3: J3.4; also elsewhere on the board
INT4: J4.4; also elsewhere on the board
INT5: J5.4; also elsewhere on the board
MISO: J1.5, J2.5, J3.5, J4.5, J5.5, U1.11; also elsewhere on the board
MISO_3v3: J6.7 (DAT0), R18.1
MOSI: J1.3, J2.3, J3.3, J4.3, J5.3, R16.1; also elsewhere on the board
MOSI_3v3: J6.3 (CMD), U1.3
unnamed: D4.2 (A), R19.2
unnamed: D7.2 (A), R20.2
unnamed: D8.2 (A), R21.2
unnamed: D9.2 (A), R22.2
unnamed: D10.2 (A), R23.2
unnamed: R15.2, U1.9
unnamed: R16.2, U1.2
unnamed: R17.2, U1.5
unnamed: R18.2, U1.12
RST1: J1.6; also elsewhere on the board
RST2: J2.6; also elsewhere on the board
RST3: J3.6; also elsewhere on the board
RST4: J4.6; also elsewhere on the board
RST5: J5.6; also elsewhere on the board
SCK: J1.7, J2.7, J3.7, J4.7, J5.7, R17.1; also elsewhere on the board
SCK_3v3: J6.5 (CLK), U1.6
USBVCC: C2.1, J1.2, J2.2, J3.2, J4.2, J5.2, U2.3 (VI); also elsewhere on the board

Notes on the sheet:
Régulateur 3v3
Conversion niveaux logiques SD
Connecteur SD
Connecteurs cartes filles

Board: 2 copper layers, 73.5 x 52.0 mm, 57 parts (0 on the bottom side), 60 nets.

## KiCad design PicoMother/PCB/PicoMother/PicoMother.kicad_pcb

Parts:
C9: 100n; C_0603_1608Metric
C10: 1u; C_0603_1608Metric
C11, C13: 22p; C_0603_1608Metric
D1: GREEN; LED_0805_2012Metric
D3: CD1206-S01575; D_1206_3216Metric
D5, D6: YELLOW; LED_0805_2012Metric
FB1: 1kΩ@100MHz; L_0805_2012Metric
J1: M20-9980345; PinHeader_2x03_P2.54mm_Vertical
J8: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
R1: 1M; R_0603_1608Metric; not fitted
R3, R4: 5k1; R_0603_1608Metric
R6: 2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9, R10: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R12: 22R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U3: ATMEGA16U2-MU; TQFP-32_7x7mm_P0.8mm
Y2: LFXTAL003240BULK; Crystal_HC49-4H_Vertical
Z1, Z2: 5pF@1MHz; R_0603_1608Metric

Connections:
+5V: C9.1, D3.1 (K), J1.2, R6.1, R8.1, R9.2, R10.2, U3.4 (VCC), U3.32 (AVCC); also elsewhere on the board
CC1: J8.A5 (CC1), R3.1
CC2: J8.B5 (CC2), R4.1
D+: J8.A6 (D+), J8.B6 (D+), R12.1, Z1.1
D-: J8.A7 (D-), J8.B7 (D-), R11.1, Z2.1
DTR: U3.13 (PD7); also elsewhere on the board
GND: C9.2, C10.1, C11.2, C13.2, D1.1 (K), FB1.2, J1.6, J8.A1 (GND), J8.A12 (GND), J8.B1 (GND), J8.B12 (GND), R3.2, R4.2, U3.3 (GND), U3.28 (UGND), U3.33 (EXP); also elsewhere on the board
M8RXD: U3.9 (PD3); also elsewhere on the board
M8TXD: U3.8 (PD2); also elsewhere on the board
MISO2: J1.1, U3.17 (PB3)
MOSI2: J1.4, U3.16 (PB2)
unnamed: D1.2 (A), R6.2
unnamed: D5.2 (A), R9.1
unnamed: D6.2 (A), R10.1
unnamed: C13.1, R1.1, U3.2 (PC0), Y2.1
unnamed: C10.2, U3.27 (UCAP)
unnamed: C11.1, R1.2, U3.1 (XTAL1), Y2.2
RD+: R12.2, U3.29 (D+)
RD-: R11.2, U3.30 (D-)
RESET2: D3.2 (A), J1.5, R8.2, U3.24 (PC1//~RESET)
RXLED: D6.1 (K), U3.10 (PD4)
SCK2: J1.3, U3.15 (PB1)
TXLED: D5.1 (K), U3.11 (PD5)
USBVCC: J8.A4 (VBUS), J8.A9 (VBUS), J8.B4 (VBUS), J8.B9 (VBUS), U3.31 (UVCC)
USHIELD: FB1.1, J8.S1 (SHIELD), Z1.2, Z2.2

Parts:
C1, C7, C8, C12: 100n; C_0603_1608Metric
D2: CD1206-S01575; D_1206_3216Metric
FB2: 10uH; L_0805_2012Metric
J3: M20-9980345; PinHeader_2x03_P2.54mm_Vertical
R2: 1M; R_0603_1608Metric; not fitted
R5, R7, R13: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_Push; SW_DIP_SPSTx01_Piano_10.8x4.1mm_W7.62mm_P2.54mm
U4: ATMEGA328P-MU; TQFP-32_7x7mm_P0.8mm
Y1: CSTNE16M0V530000R0; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm

Connections:
+5V: C8.2, D2.1 (K), FB2.1, J3.2, R14.1, U4.4 (VCC), U4.6 (VCC__1); also elsewhere on the board
A0: U4.23 (PC0)
A1: U4.24 (PC1)
A2: U4.25 (PC2)
A3: U4.26 (PC3)
A4/SDA: U4.27 (PC4)
A5/SCL: U4.28 (PC5)
AREF: C1.1, U4.20 (AREF); also elsewhere on the board
AVCC: C12.1, FB2.2, U4.18 (AVCC)
DTR: C7.1, R13.1; also elsewhere on the board
GND: C1.2, C8.1, C12.2, J3.6, R13.2, SW1.1, U4.3 (GND), U4.5 (GND__1), U4.21 (GND__2), U4.33 (EXP), Y1.2; also elsewhere on the board
IO0: R5.1, U4.30 (PD0)
IO1: R7.2, U4.31 (PD1)
IO2: U4.32 (PD2)
IO3: U4.1 (PD3)
IO4: U4.2 (PD4)
IO5: U4.9 (PD5)
IO6: U4.10 (PD6)
IO7: U4.11 (PD7)
IO8: U4.12 (PB0)
IO9: U4.13 (PB1)
M8RXD: R5.2; also elsewhere on the board
M8TXD: R7.1; also elsewhere on the board
MISO: J3.1, U4.16 (PB4); also elsewhere on the board
MOSI: J3.4, U4.15 (PB3); also elsewhere on the board
unnamed: R2.2, U4.7 (PB6), Y1.3
unnamed: R2.1, U4.8 (PB7), Y1.1
RESET: C7.2, D2.2 (A), J3.5, R14.2, SW1.2, U4.29 (PC6/~RESET)
SCK: J3.3, U4.17 (PB5); also elsewhere on the board
SS: U4.14 (PB2)

Parts:
C6: 100n; C_0603_1608Metric
D4, D7, D8, D9, D10: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J2: Micro_SD_Card_Det2; microSD_HC_Molex_104031-0811
J4, J5, J6, J7, J9: Conn_02x04_Counter_Clockwise; IDC-Header_2x04_P2.54mm_Vertical
R15, R16, R17, R18: 3.3k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R19, R20, R21, R22, R23: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: 74LVC125; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
+3V3: J2.4 (VDD), U1.14 (VCC)
+5V: J4.2, J5.2, J6.2, J7.2, J9.2; also elsewhere on the board
AREF: C6.1; also elsewhere on the board
CS1: R15.1
CS1_1: J2.2 (DAT3/CD), U1.8
CS2: J4.8, R19.1
CS3: J5.8, R20.1
CS4: J6.8, R21.1
CS5: J7.8, R22.1
CS6: J9.8, R23.1
GND: C6.2, D4.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), J2.6 (VSS), J2.11 (SHIELD), J4.1, J5.1, J6.1, J7.1, J9.1, U1.1, U1.4, U1.7 (GND), U1.10, U1.13; also elsewhere on the board
INT1: J4.4
INT2: J5.4
INT3: J6.4
INT4: J7.4
INT5: J9.4
MISO: J4.5, J5.5, J6.5, J7.5, J9.5, U1.11; also elsewhere on the board
MISO_1: J2.7 (DAT0), R18.1
MOSI: J4.3, J5.3, J6.3, J7.3, J9.3, R16.1; also elsewhere on the board
MOSI_1: J2.3 (CMD), U1.3
unnamed: D4.2 (A), R19.2
unnamed: D7.2 (A), R20.2
unnamed: D8.2 (A), R21.2
unnamed: D9.2 (A), R22.2
unnamed: D10.2 (A), R23.2
unnamed: R15.2, U1.9
unnamed: R16.2, U1.2
unnamed: R17.2, U1.5
unnamed: R18.2, U1.12
RST1: J4.6
RST2: J5.6
RST3: J6.6
RST4: J7.6
RST5: J9.6
SCK: J4.7, J5.7, J6.7, J7.7, J9.7, R17.1; also elsewhere on the board
SCK_1: J2.5 (CLK), U1.6

Notes on the sheet:
Conversion niveaux logiques
Lecteur SD
Connecteurs cartes filles

Board: 2 copper layers, 66.0 x 53.3 mm, 61 parts (0 on the bottom side), 54 nets.

## KiCad design PicoShield_B8/PicoShield.kicad_pcb

Board: 2 copper layers, 55.8 x 53.8 mm, 25 parts (4 on the bottom side), 37 nets.

Parts:
A1: Arduino_UNO_R3
D1, D2, D3, D4, D5: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1, J2, J4, J5, J6: Conn_02x04_Counter_Clockwise; IDC-Header_2x04_P2.54mm_Vertical
J8: Micro_SD_Card_Det2; microSD_HC_Molex_104031-0811
R1, R3, R4, R5: 3.3k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R6, R7, R8, R9: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10, R11: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: 74LVC125; SOIC-14_3.9x8.7mm_P1.27mm
U2: AT45DB641E; SOIC-8_5.275x5.275mm_P1.27mm

Connections:
+3V3: A1.4 (3V3), J8.4 (VDD), R10.2, R11.1, U1.14 (VCC), U2.6 (VCC)
+5V: A1.5 (+5V), J1.2, J2.2, J4.2, J5.2, J6.2
CS1: A1.25 (D10), R4.1
CS1_1: J8.2 (DAT3/CD), U1.8, U2.4 (~CS)
CS2: A1.9 (A0), J1.8, R2.1
CS3: A1.12 (A3), J2.8, R6.1
CS4: A1.16 (D1/TX), J4.8, R7.1
CS5: A1.19 (D4), J5.8, R8.1
CS6: A1.22 (D7), J6.8, R9.1
GND: A1.6 (GND), A1.7 (GND), A1.29 (GND), D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), J1.1, J2.1, J4.1, J5.1, J6.1, J8.6 (VSS), J8.11 (SHIELD), U1.1, U1.4, U1.7 (GND), U1.10, U1.13, U2.7 (GND)
INT1: A1.11 (A2), J1.4
INT2: A1.14 (SCL/A5), J2.4
INT3: A1.18 (D3), J4.4
INT4: A1.21 (D6), J5.4
INT5: A1.24 (D9), J6.4
MISO: A1.27 (D12), J1.5, J2.5, J4.5, J5.5, J6.5, U1.11
MISO_1: J8.7 (DAT0), R5.1, U2.8 (SO)
MOSI: A1.26 (D11), J1.3, J2.3, J4.3, J5.3, J6.3, R1.1
MOSI_1: J8.3 (CMD), U1.3, U2.1 (SI)
unnamed: D1.2 (A), R2.2
unnamed: D2.2 (A), R6.2
unnamed: D3.2 (A), R7.2
unnamed: D4.2 (A), R8.2
unnamed: D5.2 (A), R9.2
unnamed: R1.2, U1.2
unnamed: R3.2, U1.5
unnamed: R4.2, U1.9
unnamed: R5.2, U1.12
unnamed: R10.1, U2.3 (~RESET)
unnamed: R11.2, U2.5 (~WP)
RST1: A1.10 (A1), J1.6
RST2: A1.13 (SDA/A4), J2.6
RST3: A1.17 (D2), J4.6
RST4: A1.20 (D5), J5.6
RST5: A1.23 (D8), J6.6
SCK: A1.28 (D13), J1.7, J2.7, J4.7, J5.7, J6.7, R3.1
SCK_1: J8.5 (CLK), U1.6, U2.2 (SCK)
